# Keil uVision project Lab7.uvproj, settings and files
target Lab7 (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab7
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s PLL.c DAC.c esp8266.c ST7735.c InitAll.txt Buttons.c UART.c Thumbstick.c Accel.c Graphics.c ADC.c GameRules.cpp main.cpp PortInit.c LED.c
